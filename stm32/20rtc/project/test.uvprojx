# Keil uVision project test.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\cmsis;..\fwlib\inc;..\mylib;..\user
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ../cmsis/: core_cm3.c startup_stm32f10x_md.s
  group fwlib
    ../fwlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group mylib
    ../mylib/: led.c buzzer.c button.c delay.c eint.c iwdg.c usart1.c dht.c ldt.c adj_res.c gpio_iic.c eeprom.c sht.c oled.c rtc.c
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
